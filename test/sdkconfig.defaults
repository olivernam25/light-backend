## test/sdkconfig.defaults
```kconfig
CONFIG_ESPTOOLPY_BAUD_115200=y
CONFIG_ESPTOOLPY_BAUD=115200
CONFIG_ESPTOOLPY_NO_STUB=y
```
